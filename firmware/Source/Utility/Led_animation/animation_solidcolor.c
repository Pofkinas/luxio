/**********************************************************************************************************************
 * Includes
 *********************************************************************************************************************/

#include "animation_solidcolor.h"
#include <stddef.h>

/**********************************************************************************************************************
 * Private definitions and macros
 *********************************************************************************************************************/

#define MAX_BRIGHTNESS 255

/**********************************************************************************************************************
 * Private typedef
 *********************************************************************************************************************/

/**********************************************************************************************************************
 * Private constants
 *********************************************************************************************************************/
 
/**********************************************************************************************************************
 * Private variables
 *********************************************************************************************************************/
 
/**********************************************************************************************************************
 * Exported variables and references
 *********************************************************************************************************************/

/**********************************************************************************************************************
 * Prototypes of private functions
 *********************************************************************************************************************/
 
void Animation_SolidColor_FillBuffer (const sSolidAnimationData_t *data) {
    if (!WS2812B_API_IsCorrectDevice(data->device)) {
        return;
    }
    
    if (data == NULL) {
        return;
    }

    if (data->brightness == 0) {
        return;
    }

    uint8_t r = (data->rgb.color >> 16) & 0xFF;
    uint8_t g = (data->rgb.color >> 8) & 0xFF;
    uint8_t b = data->rgb.color & 0xFF;

    r = (r * data->brightness) / MAX_BRIGHTNESS;
    g = (g * data->brightness) / MAX_BRIGHTNESS;
    b = (b * data->brightness) / MAX_BRIGHTNESS;

    WS2812B_API_FillColor(data->device, r, g, b);

    return;
}

/**********************************************************************************************************************
 * Definitions of private functions
 *********************************************************************************************************************/
 
/**********************************************************************************************************************
 * Definitions of exported functions
 *********************************************************************************************************************/

void Animation_SolidColor_Run (const void *context) {
    Animation_SolidColor_FillBuffer((sSolidAnimationData_t*) context);
}
